# Keil uVision project STC8H_Periph_Lib.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8H_Periph_Lib +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c stc8h_gpio.c
